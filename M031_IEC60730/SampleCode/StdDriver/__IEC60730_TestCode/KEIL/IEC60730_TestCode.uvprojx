# Keil uVision project IEC60730_TestCode.uvprojx, settings and files
target IEC60730_TestCode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: IEC60730_ClassB_Test
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\post-build\AddCrc32.exe .\obj\IEC60730_ClassB_Test.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: xxDEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\post-build;..\startup;..\runtime;..\application
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\iec60730.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c clk_detect_test.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c crc.c wdt.c timer.c pwm.c spi.c adc.c
  group IEC60730_startup
    ../startup/: cpureg_test_startup.s pc_test_startup.c wdt_test_startup.c interrupt_test_startup.c flash_test_startup.c wdt_wwdt_reset_test_startup.c ram_machc_wom_test_startup.s ram_machx_wom_test_startup.s
  group IEC60730_runtime
    ../runtime/: runtime_test.c cpureg_test_runtime.s pc_test_runtime.c stack_overrun_ptrn.c stack_test_runtime.c interrupt_test_runtime.c ram_marchcx_test_runtime.c flash_test_runtime.c ram_machc_wom_test_runtime.s ram_machx_wom_test_runtime.s
  group IEC60730_application
    ../application/: application_test.c io_test.c PWM_test.c SPI_test.c AD_test.c
